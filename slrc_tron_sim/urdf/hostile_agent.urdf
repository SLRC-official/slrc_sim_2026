Commit message: commiting the uncommitted

File: slrc_tron_sim/urdf/hostile_agent.urdf (robot description, URDF)
Before this commit: robot hostile_agent, 6 links, 5 joints
Links:
- removed link led_link
Joints:
- removed joint led_fixed
